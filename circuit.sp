* Generated by json_to_spice.py
.option numdgt=8
* .option post=2   <-- REMOVE THIS LINE

V1 n_ac 0 SIN(0 325.2691193458119 50.0)
R1 n_ac n_load 100.0
R2 n_load 0 0.1
S1 n_load n_out ctl1 0 SWMODEL1
VCTL1 ctl1 0 PULSE(0 5 0 1u 1u 10u 20u)
.model SWMODEL1 SW(Ron=0.01 Roff=1000000000.0)

.tran 0.0001 0.1

.print tran time V(n_ac) I(V1) V(n_out)

.save all
.end
